#include <stdio.h>
#include <string.h>
#include <stdlib.h>

int main()
{
    int CK_A = 0;
    int CK_B = 0;
       int message[] = {0x08, 0x24, 0x24, 0x00, 0x01, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
    for (int i = 0; i < 39; i++)
    {
        CK_A = CK_A + message[i];
        CK_B = CK_B + CK_A;
    }
    if(CK_A > 0xFF)
    {
        while(CK_A > 0xFF)
            CK_A = CK_A - 0xFF;
    }
    if(CK_B > 0xFF)
    {
        while(CK_B > 0xFF)
            CK_B = CK_B - 0xFF;
    }
    printf("%X\n", CK_A);
    printf("%X\n", CK_B);
        return 0;
}